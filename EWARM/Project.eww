<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\04_H743ZI_Uart_RingBuffer.ewp</path>
  </project>
  <batchBuild />
</workspace>
